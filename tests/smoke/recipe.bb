SUMMARY = "Smoke test"
LICENSE = "MIT"
